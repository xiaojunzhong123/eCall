<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KX2026_021_TBOX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


