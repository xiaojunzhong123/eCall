# IAR project KX2026_021_TBOX.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32A4A8 XHSC HC32A4A8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG; HC32A4A8; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../common; ..\source\3_Bsw\Midwares\FreeRTOS\Source\include; ..\source\3_Bsw\Midwares\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\drivers\cmsis\Include; ..\drivers\hc32_ll_driver\inc; ..\drivers\cmsis\Device\XHSC\hc32a4xx\Include; ..\source; ..\source\6_Library; ..\source\3_Bsw\Midwares\FreeRTOS\Source\cmsis_rtos; ..\source\5_Mcal\Gpio; ..\source\2_Rte; ..\source\5_Mcal\Uart; D:\TBOX\KX2026_021_TBOX\example\source\1_App\Ecall; D:\TBOX\KX2026_021_TBOX\example\source\1_App\Hmi; D:\TBOX\KX2026_021_TBOX\example\source\3_Bsw\CanService; D:\TBOX\KX2026_021_TBOX\example\source\3_Bsw\GnssService; D:\TBOX\KX2026_021_TBOX\example\source\3_Bsw\ModemService; D:\TBOX\KX2026_021_TBOX\example\source\3_Bsw\MsgIF; D:\TBOX\KX2026_021_TBOX\example\source\3_Bsw\PowerService; D:\TBOX\KX2026_021_TBOX\example\source\4_System\Task
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\source\3_Bsw\Midwares\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: KX2026_021_TBOX.hex
  ILINK.IlinkOutputFile: hc32a4a8ritj.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_=1; _HC32A4A8_2M_=1
  ILINK.IlinkIcfFile: config/linker/HC32A4A8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: HC32A4A8; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32a4a8ritj.hex
  group (top)
    ../: Readme.txt
  group cmsis
    ./: startup_hc32a4a8ritj.s
    ../../common/: system_hc32a4a8ritj.c
  group driver
    ../drivers/hc32_ll_driver/src/: hc32_hal_can.c hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_dmc.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_ermu.c hc32_ll_eth.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mau.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_nfc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_ske.c hc32_ll_smc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32a4a8_ll_interrupts_share.c
  group source
    ../source/: main.c
  group source/1_App
    ../source/1_App/Ecall/: Ecall.c
    ../source/1_App/Hmi/: Hmi.c
  group source/2_Rte
    ../source/2_Rte/: Rte.c Rte.h RteSys.c RteSys.h
  group source/3_Bsw/CanService
    ../source/3_Bsw/CanService/: CanService.c
  group source/3_Bsw/GnssService
    ../source/3_Bsw/GnssService/: GnssService.c
  group source/3_Bsw/Midwares/FreeRTOS
    ../source/3_Bsw/Midwares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../source/3_Bsw/Midwares/FreeRTOS/Source/include/: FreeRTOSConfig.h
  group source/3_Bsw/Midwares/FreeRTOS/cmsis_rtos
    ../source/3_Bsw/Midwares/FreeRTOS/Source/cmsis_rtos/: cmsis_os.c
  group source/3_Bsw/Midwares/FreeRTOS/portable/ARM_CM4F
    ../source/3_Bsw/Midwares/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group source/3_Bsw/Midwares/FreeRTOS/portable/MemMang
    ../source/3_Bsw/Midwares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group source/3_Bsw/ModemService
    ../source/3_Bsw/ModemService/: ModemService.c
  group source/3_Bsw/MsgIF
    ../source/3_Bsw/MsgIF/: MsgIF.c MsgIF.h MsgIF_Cfg.c MsgIF_Cfg.h
  group source/3_Bsw/PowerService
    ../source/3_Bsw/PowerService/: PowerService.c
  group source/4_System/Task
    ../source/4_System/Task/: AppTask.c CanTask.c EcallTask.c GnssTask.c ModemTask.c MonitoringTask.c PowTask.c TaskManager.c
  group source/5_Mcal/Gpio
    ../source/5_Mcal/Gpio/: Gpio.c Gpio.h Gpio_Cfg.c Gpio_Cfg.h
  group source/5_Mcal/Mcu
    ../source/5_Mcal/Mcu/: Mcu.c Mcu.h Mcu_Cfg.c Mcu_Cfg.h
  group source/5_Mcal/Uart
    ../source/5_Mcal/Uart/: Uart.c Uart.h Uart_Cfg.c Uart_Cfg.h
  group source/6_Library
    ../source/6_Library/: Memory.c Memory.h Types.h
