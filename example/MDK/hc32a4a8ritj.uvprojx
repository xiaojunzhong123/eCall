# Keil uVision project hc32a4a8ritj.uvprojx, settings and files
target hc32a4a8ritj_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32A4A8RITJ XHSC
  pack: XHSC.HC32A4A8.1.0.0
  cpu: IROM1(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: hc32a4a8ritj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32A4A8,USE_DDL_DRIVER,
  c include: ../source;../../common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32A4A8xI.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32a4a8ritj.s
    ../../common/: system_hc32a4a8ritj.c
  group source
    ../source/: main.c
  group Readme
    ../: Readme.txt
target hc32a4a8ritj_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32A4A8RITJ XHSC
  pack: XHSC.HC32A4A8.1.0.0
  cpu: as above
  output: hc32a4a8ritj +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32A4A8,USE_DDL_DRIVER,
  c include: ..\source;../../common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32A4A8xI.sct
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.5.0
